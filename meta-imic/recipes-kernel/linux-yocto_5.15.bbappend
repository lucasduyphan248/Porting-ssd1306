FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Adding-folder-with-my-drivers-support-for-Beaglebone.patch \
            file://0002-Adding-config-for-DTS.patch \
            file://0003-Fix-BeagleBone-DMTimer3-interrupt-driver.patch"