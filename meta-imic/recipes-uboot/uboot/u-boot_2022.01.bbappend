FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Add the files to the SRC_URI
SRC_URI += "file://0001-cmd-adding-hello-command.patch"
